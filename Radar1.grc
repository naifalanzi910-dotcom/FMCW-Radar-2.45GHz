options:
  parameters:
    generate_options: qt_gui
    id: Radar1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: ch
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 245e7
  states: {}
- name: rfl
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: rx
  id: variable
  parameters:
    value: '1'
  states: {}
- name: spc
  id: variable
  parameters:
    value: '900'
  states: {}
- name: sr
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: vfl
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class fmcw_chirp_src(gr.sync_block):
          def __init__(self, sample_rate=30e6, bandwidth=25e6, samples_per_chirp=900, amplitude=0.5):
              gr.sync_block.__init__(self,
                  name="fmcw_chirp_src",
                  in_sig=None,
                  out_sig=[np.complex64])

              self.fs = float(sample_rate)
              self.bw = float(bandwidth)
              self.ns = int(samples_per_chirp)
              self.amp = float(amplitude)

              self.tc = self.ns / self.fs
              self.k = self.bw / self.tc

              t = np.arange(self.ns, dtype=np.float64) / self.fs
              phase = np.pi * self.k * t * t
              self.chirp = (self.amp * np.exp(1j * phase)).astype(np.complex64)
              self.idx = 0

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              for i in range(n):
                  out[i] = self.chirp[self.idx]
                  self.idx += 1
                  if self.idx >= self.ns:
                      self.idx = 0
              return n
    amplitude: '0.7'
    bandwidth: BW
    sample_rate: sr
    samples_per_chirp: spc
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import matplotlib.pyplot as plt
      from gnuradio import gr
      import pmt


      class rdm_display_block(gr.basic_block):
          """
          Display Range-Doppler Map with physical axes:
            x-axis: velocity (m/s)
            y-axis: range (m)
          """

          def __init__(self,
                       sample_rate=30e6,
                       center_freq=2.45e9,
                       bandwidth=25e6,
                       samples_per_chirp=900,
                       chirps_per_frame=128,
                       chirp_period=0.0,
                       title="Range-Doppler Map",
                       update_every=1):
              gr.basic_block.__init__(
                  self,
                  name="rdm_display_block",
                  in_sig=None,
                  out_sig=None
              )

              self.sample_rate = float(sample_rate)
              self.center_freq = float(center_freq)
              self.bandwidth = float(bandwidth)
              self.samples_per_chirp = int(samples_per_chirp)
              self.chirps_per_frame = int(chirps_per_frame)
              self.chirp_period = float(chirp_period)   # if 0, use Tc = samples_per_chirp / sample_rate
              self.title = title
              self.update_every = int(update_every)
              self.msg_count = 0

              self.c = 3e8
              self.lam = self.c / self.center_freq

              self.message_port_register_in(pmt.intern("rdm"))
              self.set_msg_handler(pmt.intern("rdm"), self.handle_msg)

              plt.ion()
              self.fig, self.ax = plt.subplots()
              self.im = None
              self.cbar = None

          def _axes(self, range_bins, doppler_bins):
              # Range
              range_res = self.c / (2.0 * self.bandwidth)
              rng_axis = np.arange(range_bins, dtype=np.float64) * range_res

              # Velocity
              if self.chirp_period > 0:
                  Tc = self.chirp_period
              else:
                  Tc = self.samples_per_chirp / self.sample_rate

              max_vel = self.lam / (4.0 * Tc)
              dop_axis = np.linspace(-max_vel, max_vel, doppler_bins, dtype=np.float64)

              return rng_axis, dop_axis

          def handle_msg(self, msg):
              self.msg_count += 1
              if self.msg_count % self.update_every != 0:
                  return

              meta = pmt.to_python(pmt.car(msg))
              data = np.array(pmt.f32vector_elements(pmt.cdr(msg)), dtype=np.float32)
              arr = data.reshape(meta["shape"])   # expected shape: [range_bins, doppler_bins]

              range_bins, doppler_bins = arr.shape
              rng_axis, dop_axis = self._axes(range_bins, doppler_bins)

              arr_db = 20.0 * np.log10(np.maximum(arr, 1e-12))

              extent = [dop_axis[0], dop_axis[-1], rng_axis[0], rng_axis[-1]]

              if self.im is None:
                  self.im = self.ax.imshow(
                      arr_db,
                      extent=extent,
                      aspect='auto',
                      origin='lower'
                  )
                  self.cbar = self.fig.colorbar(self.im, ax=self.ax)
              else:
                  self.im.set_data(arr_db)
                  self.im.set_extent(extent)
                  self.im.set_clim(vmin=np.min(arr_db), vmax=np.max(arr_db))

              self.ax.set_title(self.title)
              self.ax.set_xlabel("Velocity (m/s)")
              self.ax.set_ylabel("Range (m)")

              self.fig.canvas.draw()
              self.fig.canvas.flush_events()
    bandwidth: BW
    center_freq: fc
    chirp_period: spc/sr
    chirps_per_frame: ch
    sample_rate: sr
    samples_per_chirp: spc
    title: '''Range-Doppler Map'''
    update_every: '1'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import matplotlib.pyplot as plt
      from gnuradio import gr
      import pmt


      class cfar_display_block(gr.basic_block):
          """
          Display CFAR detection map with physical axes:
            x-axis: velocity (m/s)
            y-axis: range (m)
          """

          def __init__(self,
                       sample_rate=30e6,
                       center_freq=2.45e9,
                       bandwidth=25e6,
                       samples_per_chirp=900,
                       chirps_per_frame=128,
                       chirp_period=0.0,
                       title="CFAR Detection Map",
                       update_every=1):
              gr.basic_block.__init__(
                  self,
                  name="cfar_display_block",
                  in_sig=None,
                  out_sig=None
              )

              self.sample_rate = float(sample_rate)
              self.center_freq = float(center_freq)
              self.bandwidth = float(bandwidth)
              self.samples_per_chirp = int(samples_per_chirp)
              self.chirps_per_frame = int(chirps_per_frame)
              self.chirp_period = float(chirp_period)   # if 0, use Tc = samples_per_chirp / sample_rate
              self.title = title
              self.update_every = int(update_every)
              self.msg_count = 0

              self.c = 3e8
              self.lam = self.c / self.center_freq

              self.message_port_register_in(pmt.intern("cfar"))
              self.set_msg_handler(pmt.intern("cfar"), self.handle_msg)

              plt.ion()
              self.fig, self.ax = plt.subplots()
              self.im = None
              self.cbar = None

          def _axes(self, range_bins, doppler_bins):
              # Range
              range_res = self.c / (2.0 * self.bandwidth)
              rng_axis = np.arange(range_bins, dtype=np.float64) * range_res

              # Velocity
              if self.chirp_period > 0:
                  Tc = self.chirp_period
              else:
                  Tc = self.samples_per_chirp / self.sample_rate

              max_vel = self.lam / (4.0 * Tc)
              dop_axis = np.linspace(-max_vel, max_vel, doppler_bins, dtype=np.float64)

              return rng_axis, dop_axis

          def handle_msg(self, msg):
              self.msg_count += 1
              if self.msg_count % self.update_every != 0:
                  return

              meta = pmt.to_python(pmt.car(msg))
              data = np.array(pmt.u8vector_elements(pmt.cdr(msg)), dtype=np.uint8)
              arr = data.reshape(meta["shape"])   # expected shape: [range_bins, doppler_bins]

              range_bins, doppler_bins = arr.shape
              rng_axis, dop_axis = self._axes(range_bins, doppler_bins)

              extent = [dop_axis[0], dop_axis[-1], rng_axis[0], rng_axis[-1]]

              if self.im is None:
                  self.im = self.ax.imshow(
                      arr,
                      extent=extent,
                      aspect='auto',
                      origin='lower',
                      vmin=0,
                      vmax=1
                  )
                  self.cbar = self.fig.colorbar(self.im, ax=self.ax)
              else:
                  self.im.set_data(arr)
                  self.im.set_extent(extent)
                  self.im.set_clim(vmin=0, vmax=1)

              self.ax.set_title(self.title)
              self.ax.set_xlabel("Velocity (m/s)")
              self.ax.set_ylabel("Range (m)")

              self.fig.canvas.draw()
              self.fig.canvas.flush_events()
    bandwidth: BW
    center_freq: fc
    chirp_period: spc/sr
    chirps_per_frame: ch
    sample_rate: sr
    samples_per_chirp: spc
    title: '''CFAR Detection Map'''
    update_every: '1'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import matplotlib.pyplot as plt
      from gnuradio import gr
      import pmt


      class music_display_block(gr.basic_block):
          def __init__(self, title="Music Spectrum", update_every=1):
              gr.basic_block.__init__(
                  self,
                  name="music_display_block",
                  in_sig=None,
                  out_sig=None
              )

              self.title = title
              self.update_every = int(update_every)
              self.counter = 0

              self.message_port_register_in(pmt.intern("doa"))
              self.set_msg_handler(pmt.intern("doa"), self.handle_msg)

              plt.ion()
              self.fig, self.ax = plt.subplots()
              self.line, = self.ax.plot([], [])
              self.ax.set_title(self.title)
              self.ax.set_xlabel("Angle (deg)")
              self.ax.set_ylabel("Spectrum")
              self.ax.grid(True)
              self.fig.canvas.draw()
              self.fig.canvas.flush_events()

          def handle_msg(self, msg):
              self.counter += 1
              if self.counter % self.update_every != 0:
                  return

              meta = pmt.to_python(pmt.car(msg))
              vec = np.array(pmt.f32vector_elements(pmt.cdr(msg)), dtype=np.float32)

              if "angles_deg" in meta:
                  x = np.array(meta["angles_deg"], dtype=np.float32)
              else:
                  x = np.arange(len(vec), dtype=np.float32)

              y = vec

              if len(x) == 0 or len(y) == 0:
                  x = np.array([-90.0, 90.0], dtype=np.float32)
                  y = np.array([0.0, 0.0], dtype=np.float32)

              self.line.set_data(x, y)
              self.ax.set_xlim(float(np.min(x)), float(np.max(x)))

              ymin = float(np.min(y))
              ymax = float(np.max(y))

              if abs(ymax - ymin) < 1e-9:
                  ymin -= 0.05
                  ymax += 0.05

              self.ax.set_ylim(ymin, ymax)

              note = meta.get("note", "")
              if note:
                  self.ax.set_title(f"{self.title} - {note}")
              else:
                  self.ax.set_title(self.title)

              self.fig.canvas.draw()
              self.fig.canvas.flush_events()
    title: '''Music Spectrum'''
    update_every: '1'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class range_fft_block(gr.basic_block):
          def __init__(self, samples_per_chirp=900, chirps_per_frame=1024, range_fft_len=1024):
              gr.basic_block.__init__(self,
                  name="range_fft_block",
                  in_sig=None,
                  out_sig=None)

              self.ns = int(samples_per_chirp)
              self.nc = int(chirps_per_frame)
              self.nfft = int(range_fft_len)
              self.win = np.hanning(self.ns).astype(np.float32)

              self.message_port_register_in(pmt.intern("datacube"))
              self.message_port_register_out(pmt.intern("rng_cube"))
              self.set_msg_handler(pmt.intern("datacube"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.to_python(pmt.car(msg))
              vec = np.array(pmt.c32vector_elements(pmt.cdr(msg)), dtype=np.complex64)
              cube = vec.reshape(meta["shape"])

              out = np.zeros((cube.shape[0], self.nc, self.nfft), dtype=np.complex64)
              for rx in range(cube.shape[0]):
                  tmp = cube[rx] * self.win[None, :]
                  out[rx] = np.fft.fft(tmp, n=self.nfft, axis=1)

              new_meta = dict(meta)
              new_meta["shape"] = list(out.shape)
              new_meta["range_fft_len"] = self.nfft

              self.message_port_pub(
                  pmt.intern("rng_cube"),
                  pmt.cons(pmt.to_pmt(new_meta), pmt.init_c32vector(out.size, out.ravel()))
              )
    chirps_per_frame: ch
    range_fft_len: rfl
    samples_per_chirp: spc
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt


      class radar_cube_builder(gr.sync_block):
          """
          Real-time radar datacube builder for:
            input 0 = tx_ref
            input 1 = rx0

          Output message:
            datacube

          Datacube shape:
            (1, chirps_per_frame, samples_per_chirp)
          """

          def __init__(self, samples_per_chirp=900, chirps_per_frame=128, dechirp=True):
              self.samples_per_chirp = int(samples_per_chirp)
              self.chirps_per_frame = int(chirps_per_frame)

              if isinstance(dechirp, str):
                  self.dechirp = dechirp.strip().lower() in ("true", "1", "yes", "on")
              else:
                  self.dechirp = bool(dechirp)

              self.frame_samples = self.samples_per_chirp * self.chirps_per_frame

              gr.sync_block.__init__(
                  self,
                  name="radar_cube_builder",
                  in_sig=[np.complex64, np.complex64],   # tx_ref, rx0
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern("datacube"))

              self.tx_buf = np.zeros(0, dtype=np.complex64)
              self.rx_buf = np.zeros(0, dtype=np.complex64)

          def work(self, input_items, output_items):
              tx = input_items[0]
              rx = input_items[1]

              if len(tx) == 0 or len(rx) == 0:
                  return 0

              self.tx_buf = np.concatenate((self.tx_buf, tx))
              self.rx_buf = np.concatenate((self.rx_buf, rx))

              while len(self.tx_buf) >= self.frame_samples and len(self.rx_buf) >= self.frame_samples:
                  tx_frame = self.tx_buf[:self.frame_samples]
                  rx_frame = self.rx_buf[:self.frame_samples]

                  self.tx_buf = self.tx_buf[self.frame_samples:]
                  self.rx_buf = self.rx_buf[self.frame_samples:]

                  tx_chirps = tx_frame.reshape(self.chirps_per_frame, self.samples_per_chirp)
                  rx_chirps = rx_frame.reshape(self.chirps_per_frame, self.samples_per_chirp)

                  cube = np.zeros(
                      (1, self.chirps_per_frame, self.samples_per_chirp),
                      dtype=np.complex64
                  )

                  if self.dechirp:
                      cube[0] = rx_chirps * np.conj(tx_chirps)
                  else:
                      cube[0] = rx_chirps

                  meta = pmt.to_pmt({
                      "shape": list(cube.shape),
                      "dtype": "complex64",
                      "num_rx": 1,
                      "samples_per_chirp": self.samples_per_chirp,
                      "chirps_per_frame": self.chirps_per_frame
                  })

                  data = pmt.init_c32vector(
                      cube.size,
                      cube.ravel().tolist()
                  )

                  msg = pmt.cons(meta, data)
                  self.message_port_pub(pmt.intern("datacube"), msg)

              return min(len(tx), len(rx))
    chirps_per_frame: ch
    dechirp: 'True'
    samples_per_chirp: spc
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt


      class music_doa_block(gr.basic_block):
          def __init__(self, center_freq=2.45e9, rx_spacing_m=None, num_sources=1):
              gr.basic_block.__init__(
                  self,
                  name="music_doa_block",
                  in_sig=None,
                  out_sig=None
              )

              self.c = 3e8
              self.fc = float(center_freq)
              self.lam = self.c / self.fc
              self.d = self.lam / 2 if rx_spacing_m is None else float(rx_spacing_m)
              self.num_sources = int(num_sources)

              self.message_port_register_in(pmt.intern("rdm_per_rx"))
              self.message_port_register_out(pmt.intern("doa"))
              self.set_msg_handler(pmt.intern("rdm_per_rx"), self.handle_msg)

          def publish_spectrum(self, ang_grid, spectrum, peak_angle=0.0, note=""):
              meta = {
                  "angles_deg": ang_grid.tolist(),
                  "shape": [1, len(spectrum)],
                  "dtype": "float32",
                  "peak_angle_deg": float(peak_angle),
                  "note": note
              }
              msg = pmt.cons(
                  pmt.to_pmt(meta),
                  pmt.init_f32vector(len(spectrum), spectrum.astype(np.float32))
              )
              self.message_port_pub(pmt.intern("doa"), msg)

          def handle_msg(self, msg):
              meta = pmt.to_python(pmt.car(msg))
              vec = np.array(pmt.f32vector_elements(pmt.cdr(msg)), dtype=np.float32)

              if "shape" not in meta:
                  ang_grid = np.arange(-90.0, 90.25, 0.25, dtype=np.float32)
                  spectrum = np.zeros_like(ang_grid, dtype=np.float32)
                  self.publish_spectrum(ang_grid, spectrum, 0.0, "Missing shape metadata")
                  return

              arr = vec.reshape(meta["shape"])   # expected shape: [num_rx, range_bins, doppler_bins] or similar

              if arr.ndim < 3:
                  ang_grid = np.arange(-90.0, 90.25, 0.25, dtype=np.float32)
                  spectrum = np.zeros_like(ang_grid, dtype=np.float32)
                  self.publish_spectrum(ang_grid, spectrum, 0.0, "Input array has wrong dimensions")
                  return

              num_rx = arr.shape[0]
              ang_grid = np.arange(-90.0, 90.25, 0.25, dtype=np.float32)

              # Fallback mode for one RX: publish flat line
              if num_rx < 2:
                  spectrum = np.zeros_like(ang_grid, dtype=np.float32)
                  self.publish_spectrum(ang_grid, spectrum, 0.0, "")
                  return

              # Normal MUSIC path
              # Pick strongest range-doppler cell from summed power
              summed = np.sum(arr, axis=0)   # [range, doppler]
              peak_idx = np.unravel_index(np.argmax(summed), summed.shape)
              rbin, dbin = peak_idx

              # Snapshot vector across antennas
              x = arr[:, rbin, dbin].astype(np.complex64).reshape(-1, 1)

              # Covariance
              Rxx = x @ x.conj().T

              eigvals, eigvecs = np.linalg.eigh(Rxx)
              idx = np.argsort(eigvals)[::-1]
              eigvecs = eigvecs[:, idx]

              nsrc = min(self.num_sources, num_rx - 1)
              En = eigvecs[:, nsrc:]

              rx_pos = np.arange(num_rx, dtype=np.float32) * self.d
              spectrum = np.zeros(len(ang_grid), dtype=np.float32)

              for i, ang in enumerate(ang_grid):
                  th = np.deg2rad(ang)
                  sv = np.exp(1j * 2 * np.pi * rx_pos * np.sin(th) / self.lam).reshape(-1, 1)
                  denom = np.real((sv.conj().T @ (En @ En.conj().T) @ sv).item())
                  spectrum[i] = 1.0 / max(denom, 1e-12)

              if np.max(spectrum) > 0:
                  spectrum = spectrum / np.max(spectrum)

              peak_angle = ang_grid[np.argmax(spectrum)]
              self.publish_spectrum(ang_grid, spectrum, peak_angle, "Normal MUSIC")
    center_freq: fc
    num_sources: '1'
    rx_spacing_m: '0.0612'
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class cfar2d_block(gr.basic_block):
          def __init__(self, tr=8, td=8, gr_=1, gd=1, pfa=1e-6):
              gr.basic_block.__init__(self,
                  name="cfar2d_block",
                  in_sig=None,
                  out_sig=None)

              self.tr = int(tr)
              self.td = int(td)
              self.gr = int(gr_)
              self.gd = int(gd)
              self.pfa = float(pfa)

              self.message_port_register_in(pmt.intern("rdm"))
              self.message_port_register_out(pmt.intern("cfar"))
              self.set_msg_handler(pmt.intern("rdm"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.to_python(pmt.car(msg))
              vec = np.array(pmt.f32vector_elements(pmt.cdr(msg)), dtype=np.float32)
              RDM = vec.reshape(meta["shape"])

              rows, cols = RDM.shape
              CFAR = np.zeros_like(RDM, dtype=np.uint8)

              N = (2*(self.tr+self.gr)+1)*(2*(self.td+self.gd)+1) - (2*self.gr+1)*(2*self.gd+1)
              alpha = N * (self.pfa ** (-1.0 / N) - 1.0)

              for i in range(self.tr + self.gr, rows - (self.tr + self.gr)):
                  for j in range(self.td + self.gd, cols - (self.td + self.gd)):
                      w = RDM[i-(self.tr+self.gr):i+(self.tr+self.gr)+1,
                              j-(self.td+self.gd):j+(self.td+self.gd)+1].copy()

                      w[self.tr:self.tr+2*self.gr+1, self.td:self.td+2*self.gd+1] = 0.0
                      noise = np.sum(w) / N
                      thr = alpha * noise

                      if RDM[i, j] > thr:
                          CFAR[i, j] = 1

              new_meta = dict(meta)
              new_meta["shape"] = list(CFAR.shape)

              self.message_port_pub(
                  pmt.intern("cfar"),
                  pmt.cons(pmt.to_pmt(new_meta), pmt.init_u8vector(CFAR.size, CFAR.ravel().tolist()))
              )
    gd: '1'
    gr_: '1'
    pfa: '1e-6'
    td: '8'
    tr: '8'
  states: {}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class doppler_fft_block(gr.basic_block):
          def __init__(self, chirps_per_frame=1024, range_fft_len=1024, doppler_fft_len=2048):
              gr.basic_block.__init__(self,
                  name="doppler_fft_block",
                  in_sig=None,
                  out_sig=None)

              self.nc = int(chirps_per_frame)
              self.nr = int(range_fft_len)
              self.nd = int(doppler_fft_len)
              self.win = np.hanning(self.nc).astype(np.float32)

              self.message_port_register_in(pmt.intern("rng_cube"))
              self.message_port_register_out(pmt.intern("rdm"))
              self.message_port_register_out(pmt.intern("rdm_per_rx"))
              self.set_msg_handler(pmt.intern("rng_cube"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.to_python(pmt.car(msg))
              vec = np.array(pmt.c32vector_elements(pmt.cdr(msg)), dtype=np.complex64)
              cube = vec.reshape(meta["shape"])   # [rx, chirp, range]

              num_rx = cube.shape[0]
              rdm_per_rx = np.zeros((num_rx, self.nr, self.nd), dtype=np.float32)

              for rx in range(num_rx):
                  tmp = cube[rx] * self.win[:, None]
                  dop = np.fft.fftshift(np.fft.fft(tmp, n=self.nd, axis=0), axes=0)  # [doppler, range]
                  rdm_per_rx[rx] = np.abs(dop.T).astype(np.float32)                   # [range, doppler]

              rdm = np.sum(rdm_per_rx, axis=0)
              p = rdm ** 2
              if np.max(p) > 0:
                  p /= np.max(p)

              meta_rdm = dict(meta)
              meta_rdm["shape"] = list(p.shape)
              meta_rdm["doppler_fft_len"] = self.nd

              self.message_port_pub(
                  pmt.intern("rdm"),
                  pmt.cons(pmt.to_pmt(meta_rdm), pmt.init_f32vector(p.size, p.ravel()))
              )

              meta_rx = dict(meta)
              meta_rx["shape"] = list(rdm_per_rx.shape)
              self.message_port_pub(
                  pmt.intern("rdm_per_rx"),
                  pmt.cons(pmt.to_pmt(meta_rx), pmt.init_f32vector(rdm_per_rx.size, rdm_per_rx.ravel()))
              )
    chirps_per_frame: ch
    doppler_fft_len: vfl
    range_fft_len: rfl
  states: {}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt


      class matched_filter_block(gr.basic_block):
          """
          Message-based matched filter block for FMCW radar datacube.

          Input message:
            datacube  -> complex cube with shape (1, chirps_per_frame, samples_per_chirp)

          Output message:
            datacube  -> filtered complex cube with same shape

          This block generates the transmit reference chirp internally and applies
          a matched filter along the fast-time (samples-per-chirp) axis.
          """

          def __init__(self,
                       sample_rate=30e6,
                       bandwidth=25e6,
                       samples_per_chirp=900,
                       chirps_per_frame=128,
                       amplitude=1.0):
              gr.basic_block.__init__(
                  self,
                  name="matched_filter_block",
                  in_sig=None,
                  out_sig=None
              )

              self.sample_rate = float(sample_rate)
              self.bandwidth = float(bandwidth)
              self.samples_per_chirp = int(samples_per_chirp)
              self.chirps_per_frame = int(chirps_per_frame)
              self.amplitude = float(amplitude)

              self.message_port_register_in(pmt.intern("datacube"))
              self.message_port_register_out(pmt.intern("datacube"))
              self.set_msg_handler(pmt.intern("datacube"), self.handle_msg)

              # build reference chirp
              self._build_reference()

          def _build_reference(self):
              t = np.arange(self.samples_per_chirp, dtype=np.float64) / self.sample_rate
              Tc = self.samples_per_chirp / self.sample_rate
              k = self.bandwidth / Tc

              tx_chirp = self.amplitude * np.exp(1j * np.pi * k * t * t)
              self.tx_chirp = tx_chirp.astype(np.complex64)

              # matched filter impulse response: time-reversed conjugate
              self.h = np.conj(self.tx_chirp[::-1]).astype(np.complex64)

              # FFT size for fast convolution
              self.nfft = 1
              needed = self.samples_per_chirp + len(self.h) - 1
              while self.nfft < needed:
                  self.nfft *= 2

              self.H = np.fft.fft(self.h, n=self.nfft)

          def _matched_filter_1d(self, x):
              X = np.fft.fft(x, n=self.nfft)
              y = np.fft.ifft(X * self.H)

              # full convolution length
              y = y[:len(x) + len(self.h) - 1]

              # center crop back to original length
              start = (len(self.h) - 1) // 2
              end = start + len(x)
              y_same = y[start:end]

              return y_same.astype(np.complex64)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              meta_py = pmt.to_python(meta)
              shape = meta_py["shape"]

              vec = np.array(pmt.c32vector_elements(data), dtype=np.complex64)
              cube = vec.reshape(shape)

              # expected current shape: (1, chirps_per_frame, samples_per_chirp)
              out = np.zeros_like(cube, dtype=np.complex64)

              num_rx = cube.shape[0]
              num_chirps = cube.shape[1]

              for rx in range(num_rx):
                  for ch in range(num_chirps):
                      out[rx, ch, :] = self._matched_filter_1d(cube[rx, ch, :])

              out_meta = dict(meta_py)
              out_meta["matched_filter"] = True

              out_pmt = pmt.init_c32vector(out.size, out.ravel().tolist())
              self.message_port_pub(
                  pmt.intern("datacube"),
                  pmt.cons(pmt.to_pmt(out_meta), out_pmt)
              )
    amplitude: '1'
    bandwidth: BW
    chirps_per_frame: ch
    sample_rate: sr
    samples_per_chirp: spc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: BW
    center_freq0: fc
    gain0: '76'
    samp_rate: sr
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: BW
    center_freq0: fc
    gain0: '85'
    samp_rate: sr
    sync: sync
    type: fc32
  states: {}

connections:
- [epy_block_0, '0', epy_block_5, '0']
- [epy_block_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_4, rng_cube, epy_block_8, rng_cube]
- [epy_block_5, datacube, epy_block_9, datacube]
- [epy_block_6, doa, epy_block_3, doa]
- [epy_block_7, cfar, epy_block_2, cfar]
- [epy_block_8, rdm, epy_block_1, rdm]
- [epy_block_8, rdm, epy_block_7, rdm]
- [epy_block_8, rdm_per_rx, epy_block_6, rdm_per_rx]
- [epy_block_9, datacube, epy_block_4, datacube]
- [uhd_usrp_source_0, '0', epy_block_5, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
